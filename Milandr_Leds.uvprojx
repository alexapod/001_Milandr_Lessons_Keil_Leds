# Keil uVision project Milandr_Leds.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.3.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Milandr_Leds +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group usr
    ./: main.c
software components: CMSIS:CORE 6.2.0, Device:Startup 2.2.0i, Drivers:PORT 2.2.0i, Drivers:RST_CLK 2.2.0i
